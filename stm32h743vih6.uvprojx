# Keil uVision project stm32h743vih6.uvprojx, settings and files
target stm32h743vih6 (6140000::V6.14::ARMCLANG)
  device: STM32H743VIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: stm32h743vih6 +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM7,ARM_MATH_ROUNDING,__TARGET_FPU_VFP
  c include: .\include;.\include\cmsis;.\include\machine;.\include\math;.\lib\STM32H7xx_HAL_Driver\Inc;.\lib\STM32H7xx_HAL_Driver\Inc\Legacy;.\main;.\thirdParty\rt-thread-all\components\finsh;.\thirdParty\rt-thread-all\include;.\thirdParty\rt-thread-all\include\libc;.\thirdParty\rt-thread-all\user;.\thirdParty\rt-thread-all\bsp\stm32\libraries\HAL_Drivers\config\h7;.\thirdParty\rt-thread-all\bsp\stm32\libraries\HAL_Drivers;.\thirdParty\rt-thread-all\components\drivers\include;.\thirdParty\rt-thread-all\components\drivers\include\ipc;.\thirdParty\rt-thread-all\components\drivers\include\drivers;.\thirdParty\rt-thread-all\components\drivers\hwcrypto;.\thirdParty\rt-thread-all\components\drivers\include\ipc;.\thirdParty\rt-thread-all\components\libc\compilers\common;.\thirdParty\rt-thread-all\components\drivers\spi;.\thirdParty\rt-thread-all\components\drivers\spi\sfud\inc;.\thirdParty\rt-thread-all\user\AppDrivers\include;.\thirdParty\rt-thread-all\components\drivers\sdio;.\thirdParty\rt-thread-all\components\dfs\include;.\thirdParty\rt-thread-all\components\dfs\filesystems\devfs;.\thirdParty\rt-thread-all\components\dfs\filesystems\elmfat;.\thirdParty\rt-thread-all\components\dfs\filesystems\ramfs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\core\h7.sct
  group Core
    ./core/: stm32h7xx_hal_msp.c stm32h7xx_it.c system_stm32h7xx.c
    ./core/startup/: startup_stm32h743xx.s
  group Main
    ./main/: main.c sys_conf.c
    ./include/: pro_conf.h
  group Lib
    ./lib/: arm_cortexM4lf_math.lib arm_cortexM7lfdp_math.lib
    ./lib/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cordic.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dfsdm_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_dts.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_fmac.c stm32h7xx_hal_gfxmmu.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_ospi.c stm32h7xx_hal_otfdec.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pssi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_cordic.c stm32h7xx_ll_crc.c stm32h7xx_ll_crs.c stm32h7xx_ll_dac.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_fmac.c stm32h7xx_ll_fmc.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_usb.c stm32h7xx_ll_utils.c
  group App/driver
    ./thirdParty/rt-thread-all/user/AppDrivers/: w25qxx_driver_for_rtt.c sdmmc_driver_for_rtt.c
  group ThridParty/rtt/kernal
    ./thirdParty/rt-thread-all/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
    ./thirdParty/rt-thread-all/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ./thirdParty/rt-thread-all/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group ThridParty/rtt/finsh
    ./thirdParty/rt-thread-all/components/finsh/: cmd.c msh.c shell.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh_file.c symbol.c
  group ThridParty/rtt/driver_core
    ./thirdParty/rt-thread-all/components/drivers/serial/: serial.c
    ./thirdParty/rt-thread-all/components/drivers/misc/: pin.c
    ./thirdParty/rt-thread-all/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ./thirdParty/rt-thread-all/components/drivers/rtc/: rtc.c
    ./thirdParty/rt-thread-all/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c qspi_core.c
    ./thirdParty/rt-thread-all/components/drivers/sdio/: block_dev.c sdio.c sd.c mmcsd_core.c mmc.c
  group ThridParty/rtt/driver
    ./thirdParty/rt-thread-all/bsp/stm32/libraries/HAL_Drivers/drv_flash/: drv_flash_h7.c
    ./thirdParty/rt-thread-all/bsp/stm32/libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_rtc.c drv_spi.c drv_usart.c drv_qspi.c drv_sdio.c drv_lcd.c drv_sdram.c
    ./thirdParty/rt-thread-all/components/drivers/hwcrypto/: hwcrypto.c
  group ThridParty/rtt/libc
    ./thirdParty/rt-thread-all/components/libc/compilers/common/: time.c
  group ThridParty/rtt/sfud
    ./thirdParty/rt-thread-all/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group ThridParty/rtt/dfs/core
    ./thirdParty/rt-thread-all/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ./thirdParty/rt-thread-all/components/dfs/filesystems/devfs/: devfs.c
  group ThridParty/rtt/dfs/elmfs
    ./thirdParty/rt-thread-all/components/dfs/filesystems/elmfat/: ff.c dfs_elm.c ffconf.h
    ./thirdParty/rt-thread-all/components/dfs/filesystems/elmfat/option/: unicode.c syscall.c ccfile.c
  group ThridParty/rtt/dfs/ramfs
    ./thirdParty/rt-thread-all/components/dfs/filesystems/ramfs/: dfs_ramfs.c
  group ThridParty/rtt/user
    ./thirdParty/rt-thread-all/user/: board.c board.h rtconfig.h
    ./thirdParty/rt-thread-all/user/AppDrivers/: cmd_user.c
target NoOS (6140000::V6.14::ARMCLANG)
  device: STM32H743VIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: stm32h743vih6 +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c include: .\include;.\include\cmsis;.\include\machine;.\include\math;.\lib\STM32H7xx_HAL_Driver\Inc;.\lib\STM32H7xx_HAL_Driver\Inc\Legacy;.\main;.\thirdParty\rt-thread-all\components\finsh;.\thirdParty\rt-thread-all\include;.\thirdParty\rt-thread-all\include\libc;.\thirdParty\rt-thread-all\user;.\thirdParty\rt-thread-all\bsp\stm32\libraries\HAL_Drivers\config\h7;.\thirdParty\rt-thread-all\bsp\stm32\libraries\HAL_Drivers;.\thirdParty\rt-thread-all\components\drivers\include;.\thirdParty\rt-thread-all\components\drivers\include\ipc;.\thirdParty\rt-thread-all\components\drivers\include\drivers;.\thirdParty\rt-thread-all\components\drivers\hwcrypto;.\thirdParty\rt-thread-all\components\drivers\include\ipc;.\thirdParty\rt-thread-all\components\libc\compilers\common;.\thirdParty\rt-thread-all\components\drivers\spi;.\thirdParty\rt-thread-all\components\drivers\spi\sfud\inc;.\thirdParty\rt-thread-all\user\AppDrivers\include;.\thirdParty\rt-thread-all\components\drivers\sdio;.\thirdParty\rt-thread-all\components\dfs\include;.\thirdParty\rt-thread-all\components\dfs\filesystems\devfs;.\thirdParty\rt-thread-all\components\dfs\filesystems\elmfat
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\core\h7.sct
